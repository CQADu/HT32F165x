# Keil uVision project Project_1654.uvprojx, settings and files
target HT32 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: HT32F1654 Holtek
  pack: Holtek.HT32_DFP.1.0.16
  cpu: IROM(0x00000000-0x0000FBFF) IRAM(0x20000000-0x20003FFF) CPUTYPE("Cortex-M3") CLOCK(8000000)
  output: HT32 +hex
  AfterMake: fromelf --bin -o #L.bin #L
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F1654_DVB, USE_HT32F1653_54, USE_MEM_HT32F1654
  c include: ..\;..\..\..\..\library\HT32F1xxxx_Driver\inc;..\..\..\..\library\CMSIS\Include;..\..\..\..\library\Device\Holtek\HT32F1xxxx\Include;..\..\..\..\library\HT32_USBD_Library\inc;..\..\..\..\utilities
  asm define: USE_HT32_CHIP=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xfc00
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --entry Reset_Handler
  group User
    ../: main.c ht32f1xxxx_01_it.c
  group Config
    ../: ht32f1xxxx_conf.h ht32f1xxxx_01_usbdconf.h
    ./: ht32_op.s HT32F1xxxx_01_DebugSupport.ini
  group CMSIS
    ../: system_ht32f1xxxx_01.c
  group MDK-ARM
    ./: startup_ht32f1xxxx_01.s
  group USBD_Library
    ../../../../library/HT32_USBD_Library/src/: ht32_usbd_core.c
  group Library
    ../../../../library/HT32F1xxxx_Driver/src/: ht32_cm3_misc.c ht32f1xxxx_adc.c ht32f1xxxx_bftm.c ht32f1xxxx_ckcu.c ht32f1xxxx_cmp.c ht32f1xxxx_crc.c ht32f1xxxx_ebi.c ht32f1xxxx_exti.c ht32f1xxxx_flash.c ht32f1xxxx_gpio.c ht32f1xxxx_i2c.c ht32f1xxxx_i2s.c ht32f1xxxx_mctm.c ht32f1xxxx_pdma.c ht32f1xxxx_pwrcu.c ht32f1xxxx_rstcu.c ht32f1xxxx_rtc.c ht32f1xxxx_sci.c ht32f1xxxx_spi.c ht32f1xxxx_tm.c ht32f1xxxx_usart.c ht32f1xxxx_usbd.c ht32f1xxxx_wdt.c
  group Retarget
    ../../../../library/HT32F1xxxx_Driver/src/: ht32_retarget.c ht32_serial.c
  group Utilities
    ../../../../utilities/: ht32_board.c
    ../../../../utilities/common/: i2c_eeprom.c spi_flash.c ebi_lcd.c
  group Doc
    ../: readme.txt
